		ORG 00H
		SJMP BASLA
		
		ORG 0BH
KESME_TR0:
		DEC R0
		MOV TH0,#HIGH(15536)
		MOV TL0,#LOW(15536)
		RETI
		
		ORG 30H
BASLA:
		MOV p3,#00H
		MOV p2,#00H
		SETB p1.0
BUTON_BASILDI_MI:
		JB p1.0,BUTON_BASILDI_MI
BUTON_BIRAKILDI_MI:
		JB p1.0,BUTON_BASILDI_MI
	
		MOV p3,#08H
		MOV p2,#30H
		ACALL DELAY3

		MOV p3,#04H   
		MOV p2,#7DH
		ACALL DELAY3
		       
		MOV p3,#02H   
		MOV p2,#55H
		ACALL DELAY3
		
		MOV p3,#01H
		MOV p2,#1FH		
		ACALL DELAY3

		MOV p3,#08H
		MOV p2,#00H
		MOV p3,#04H
		MOV p2,#00H
		MOV p3,#02H
		MOV p2,#00H
		MOV p3,#01H
		MOV p2,#00H		
		;ACALL DELAY_1S
		
		SJMP BUTON_BIRAKILDI_MI

		
DELAY_1S:
		MOV R0,#20 ;20X5000 donmeli
		MOV IE,#82H ;EA=1 ET0=1 TIMER0 aktif
		MOV TMOD,#01
		MOV TH0,#HIGH(15536)
		MOV TL0,#LOW(15536)	
		SETB TR0		
DELAY2:	CJNE R0,#00H,DELAY2
		RET

DELAY3:	MOV R0,#255
		MOV R1,#255
HERE0:	DJNZ R0,HERE1
		
HERE1:	DJNZ R1,HERE1
		RET
		
		END
			
